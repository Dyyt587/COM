# Keil uVision project STM32H7B0.uvprojx, settings and files
target STM32H7B0 (6190000::V6.19::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B0xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/cpost/src;../Middlewares/easylogger/inc;../Middlewares/easylogger/plugins/flash;../Middlewares/easylogger/port;../Middlewares/sfsm;../Middlewares/sfsm/sfmem;../Middlewares/sfsm/config;../Middlewares/SFUD/sfud/inc;../Drivers/User/Inc;../Middlewares/LetterShell/src;../Middlewares/FlashDB/inc;../Middlewares/FlashDB/port/fal/inc;../Middlewares/FlashDB/port/fal/samples/porting;../Middlewares/perf_counter;../unity/Inc;..\..\..\com\src
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Application/MDK-ARM
    ./: startup_stm32h7b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma2.c dma.c dma2d.c i2c.c ltdc.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LetterShell
    ../Middlewares/LetterShell/src/: commend.c shell.c shell_cmd_list.c shell_companion.c shell_ext.c shell_port.c
  group Middlewares/EasyLogger
    ../Middlewares/easylogger/src/: elog.c elog_buf.c elog_utils.c elog_async.c
    ../Middlewares/easylogger/port/: elog_port.c
  group Middlewares/cpost
    ../Middlewares/cpost/src/: cevent.c cpost.c
  group Middlewares/SFUD
    ../Middlewares/SFUD/sfud/src/: sfud.c sfud_sfdp.c
    ../Middlewares/SFUD/sfud/port/: sfud_port.c
  group Middlewares/SFSM
    ../Middlewares/sfsm/: sfsm.c
    ../Middlewares/sfsm/sfmem/: sfmem.c
  group Units
    ../unity/Src/: unity.c
  group BSP
    ../Drivers/User/Src/: led.c common.c dqueue.c sht30.c tim_pwm.c ins330.c
    ./: com_uart_port.c
    ../../../com/src/: com_component.c com_component_i2c.c com_component_spi.c com_component_uart.c kfifo.c
  group Middlewares/FlashDB
    ../Middlewares/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    ../Middlewares/FlashDB/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group Middlewares/FAL
    ../Middlewares/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c
    ../Middlewares/FlashDB/port/fal/samples/porting/: fal_cfg.h fal_flash_sfud_port.c
  group pref_counter
    ../Middlewares/perf_counter/: perf_counter.c
  group TEST
    ../unity/: test.cpp
software components: CMSIS:CORE 5.6.0
